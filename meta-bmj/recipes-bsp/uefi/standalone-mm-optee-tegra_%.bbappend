FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-disable-var-store-integrity-check.patch;patchdir=../edk2-nvidia"
